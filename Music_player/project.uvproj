# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: Music_player +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c music.c songs.h keypad.c keypad.h lcd1602.c lcd1602.h delay.c delay.h
