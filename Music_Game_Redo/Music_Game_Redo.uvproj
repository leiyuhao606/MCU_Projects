# Keil uVision project Music_Game_Redo.uvproj, settings and files
target Music_Game_Redo (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: Music_Game_Redo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;D:\Keil5\C51\INC\Atmel
  asm include: .;D:\Keil5\C51\INC\Atmel
  group Source Group 1
    ./: main.c music.c songs.h charts.h keypad.c keypad.h lcd1602.c lcd1602.h delay.c delay.h REGX52.H
